# Keil uVision project servo_door.uvprojx, settings and files
target ServoDoor (6070000::V6.7::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(8000000) ELITTLE
  output: servo_door +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=3
  c undefine: .
  c misc: -std=c11 -ffreestanding -fno-builtin
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\servo_door.sct
  link misc: --entry=Reset_Handler --keep=startup.o(RESET)
  group Application
    ./: startup.c main.c board.c protocol.c
